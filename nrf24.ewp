# IAR project nrf24.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x40
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m328p ATmega328P
  ICCAVR.IExtraOptions: -DCONFIG_FILE="$PROJ_FNAME$_config.h"
  ICCAVR.newCCIncludePaths: lib
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm328p.xcl
  XLINK.XExtraOptions: -Ointel-standard,(CODE)=.hex; -Ointel-standard,(XDATA)=.eep
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.GenDeviceSelectMenu: 3
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    nrf24.lib/examples/rx/: main.c
    nrf24.lib/examples/tx/: main.c
    ./: nrf24.c nrf24_config.h nrf_register.txt
  group lib
    lib/: dispatcher.c dispatcher.h itoa.c itoa.h kbd.c kbd.h lib.h uart.c uart.h
  group nrf24.lib
    nrf24.lib/src/: nrf24l01-mnemonics.h nrf24l01.c nrf24l01.h
