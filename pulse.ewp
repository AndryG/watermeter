# IAR project pulse.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-1s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m8 ATmega8
  ICCAVR.CCDiagSuppress: Pe009
  ICCAVR.newCCIncludePaths: lib
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm8.xcl
  XLINK.XExtraOptions: -Ointel-standard,(CODE)=.hex; -Ointel-standard,(XDATA)=.eep
  group (top)
    ./: adc.c adc.h config.h disk.c disk3a.c main.c pwm.c
  group lib
    lib/: dispatcher.c dispatcher.h itoa.c itoa.h kbd.c kbd.h uart.c uart.h
