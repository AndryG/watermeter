<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\nrf24.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pulse.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\wtrm.ewp</path>
    </project>
    <batchBuild />
</workspace>
